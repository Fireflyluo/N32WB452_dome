# Keil uVision project dame.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: N32WB452CEQ6 Nationstech
  pack: Nationstech.N32WB452_DFP.1.1.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dame
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: N32WB452, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS\core;..\..\Libraries\CMSIS\device;..\..\Libraries\CMSIS\device\startup;..\..\Libraries\n32wb452_algo_lib\inc;..\..\Libraries\n32wb452_ble_driver\inc;..\..\Libraries\n32wb452_std_periph_driver\inc;..\..\Libraries\n32wb452_usbfs_driver\inc;..\..\Application\Inc;..\..\BSP\Device_REG;..\..\BSP\MCU_Peripheral\Inc;..\..\Drivers;..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group Include
    ../../Include/: ioconfig.h
  group Application
    ../../Application/Src/: main.c n32wb452_it.c
    ../../Application/Inc/: main.h n32wb452_it.h
  group BSP/MCU_Peripheral
    ../../BSP/MCU_Peripheral/Src/: bsp_i2c.c bsp_gpio.c bsp_uart.c
    ../../BSP/MCU_Peripheral/Inc/: bsp_i2c.h bsp_gpio.h bsp_uart.h
  group Libraries
    ../../Libraries/n32wb452_std_periph_driver/src/: misc.c n32wb452_adc.c n32wb452_bkp.c n32wb452_can.c n32wb452_crc.c n32wb452_dac.c n32wb452_dbg.c n32wb452_dma.c n32wb452_dvp.c n32wb452_exti.c n32wb452_flash.c n32wb452_gpio.c n32wb452_i2c.c n32wb452_iwdg.c n32wb452_pwr.c n32wb452_rcc.c n32wb452_rtc.c n32wb452_sdio.c n32wb452_spi.c n32wb452_tim.c n32wb452_tsc.c n32wb452_usart.c n32wb452_wwdg.c
  group star
    ../../Libraries/CMSIS/device/: system_n32wb452.c
    ../../Libraries/CMSIS/device/startup/: startup_n32wb452.s
