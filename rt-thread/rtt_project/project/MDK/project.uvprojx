# Keil uVision project project.uvprojx, settings and files
target rt-thread (6190000::V6.19::ARMCLANG)
  device: N32WB452CEQ6 Nationstech
  pack: Nationstech.N32WB452_DFP.1.1.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: N32WB452, RT_USING_ARMLIBC, __RTTHREAD__, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\..\libraries\n32_drivers;..\..\libraries\N32WB452_Firmware_Library\CMSIS\device;..\..\rt-thread\components\drivers\include;..\..;..\..\rt-thread\components\drivers\include;..\..\hal;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\libc\posix\io\poll;..\..\applications;..\..\rt-thread\components\drivers\include;..\..\rt-thread\libcpu\arm\cortex-m4;..\..\rt-thread\components\libc\posix\io\epoll;..\..\libraries\n32_drivers\config;..\..\rt-thread\components\libc\posix\io\eventfd;..\..\rt-thread\components\libc\compilers\common\extension\fcntl\octal;..\..\board;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\libraries\N32WB452_Firmware_Library\n32wb452_std_periph_driver\inc;..\..\rt-thread\components\finsh;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\libraries\N32WB452_Firmware_Library\CMSIS\core;..\..\rt-thread\components\libc\compilers\common\extension;..\..\rt-thread\components\libc\compilers\common\include;..\..\rt-thread\components\drivers\spi;..\..\rt-thread\components\libc\posix\ipc;..\..\rt-thread\components\drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: ..\..\board\linker_scripts\link.sct
  group Applications
    ../../applications/: main.c
  group Compiler
    ../../rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../rt-thread/components/drivers/can/: can.c
    ../../rt-thread/components/drivers/core/: device.c
    ../../rt-thread/components/drivers/hwtimer/: hwtimer.c
    ../../rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rt-thread/components/drivers/misc/: adc.c dac.c
    ../../rt-thread/components/drivers/pin/: pin.c
    ../../rt-thread/components/drivers/rtc/: rtc.c
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    ../../rt-thread/components/drivers/watchdog/: watchdog.c
  group Drivers
    ../../board/: board.c
    ../../libraries/N32WB452_Firmware_Library/CMSIS/device/startup/: startup_n32wb452.s
    ../../libraries/n32_drivers/: drv_adc.c drv_can.c drv_dac.c drv_gpio.c drv_hwtimer.c drv_i2c.c drv_rtc.c drv_spi.c drv_usart.c drv_wdt.c
  group Finsh
    ../../rt-thread/components/finsh/: msh_parse.c shell.c msh.c cmd.c
  group Hardware
    ../../hal/: test.c
  group Kernel
    ../../rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../../libraries/N32WB452_Firmware_Library/n32wb452_std_periph_driver/src/: n32wb452_usart.c n32wb452_tim.c n32wb452_exti.c n32wb452_rtc.c n32wb452_bkp.c n32wb452_can.c n32wb452_spi.c n32wb452_rcc.c n32wb452_gpio.c n32wb452_iwdg.c n32wb452_adc.c n32wb452_i2c.c n32wb452_pwr.c n32wb452_dac.c misc.c n32wb452_wwdg.c
    ../../libraries/N32WB452_Firmware_Library/CMSIS/device/: system_n32wb452.c
software components: CMSIS:CORE 6.1.0
